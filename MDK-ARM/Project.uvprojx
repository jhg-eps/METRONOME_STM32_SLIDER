# Keil uVision project Project.uvprojx, settings and files
target STM32L152D_EVAL (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L152ZD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152D_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L152xD,USE_HAL_DRIVER,USE_STM32L152D_EVAL,TSLPRM_STM8L1XX_SW_ACQ,TSLPRM_STM32L1XX_SW_ACQ
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L152D_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU;..\..\..\..\..\..\Middlewares\ST\STM32_TouchSensing_Library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_pwr.c
  group Application/User
    ../Src/: main.c stmCriticalSection.c tsl_user.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32l152xd.s
  group Middlewares/STM32_TouchSensing_Library
    ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl_filter.c tsl_acq.c tsl_time.c tsl_acq_stm32l1xx_sw.c tsl_time_stm32l1xx.c tsl_dxs.c tsl_touchkey.c tsl_object.c tsl_ecs.c tsl.c tsl_linrot.c tsl_globals.c
  group Drivers/BSP/STM32L152D_EVAL
    ../../../../../../Drivers/BSP/STM32L152D_EVAL/: stm32l152d_eval.c
software components: CMSIS:CORE 4.1.0
